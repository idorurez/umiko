# Repository idorurez/umiko

File README.md (part):

# umiko

## About

*umiko* (Japanese: **海** sea + **子** an affectionate diminutive) is a split, low-profile TKL F-row-less mechanical keyboard PCB. The split sits between your hands like the trough between two waves; typed at speed on Gateron KS-33 low-profile blues, the rolling clicks sound like waves breaking on sand.

This branch (`rev2`) is the hybrid-switch revision: MX-or-KS-33 footprints, 4020 side-view underglow, 127 LEDs total. `main` is the original rev1 KS-33-only board.

## Features

* **Split layout** — two physically separate halves; each half has its own MCU and runs standalone
* **TKL, F-row-less** — full alpha + nav cluster on the right, no function row
* **Per-key RGB** (SK6812MINI-E reverse-mount, lights through PCB cutouts to underside of keycap)
* **Underglow** (SK6812 4020 side-view, edge-mounted outward-facing, single GP25 chain per half, no satellite board — 64 total: 30 left + 34 right)
* **Hybrid MX / Gateron KS-33 low-profile hot-swap** switches — one footprint accepts either switch type; flip the 3D visualization with `python scripts/toggle_switch_3d.py mx|lowpro|hide` (KiCad closed)
* **Kailh Choc V2 stabilizers** (stabilizer cutouts on PCB sized for Choc V2, not MX stabs)
* **Side-mounted host USB-C** per half (on the outer edge of each board) for host connection and power
* **Top-mounted USB-C inter-half link** (HRO Type-C, on the top edge of each board near the inner-top corner) carrying single-wire PIO serial (over D+), GND, and 5 V bridge between halves
* **RP2040** — one per half, each with its own external QSPI flash (W25Q128) and 3V3 LDO (LP5907)
* **BOOTSEL-only flashing** — each half has a BOOTSEL button (SW1 left, SW2 right). No reset circuit by design; flashing is via "unplug USB → hold BOOTSEL → plug USB → release → drop .uf2"
* **SWD test points** — 8 pads per half organized as a pogo-clip pattern (CLK/IO/GND/3V3); pads mirrored across halves so a flipped 6-pin clip lands on matching signals
* **4-layer PCB** with split L/R rails — F.Cu signal/copper, In1.Cu split 3V3 planes (L/R), In2.Cu split GND planes (L/R), B.Cu signal/copper
* **QMK firmware**

## Hardware Specs

| | |
|--|--|
| **Dimensions** | 328.62 × 102.85 mm (end-to-end, both halves + 13.11 mm inter-half gap). Left half 145.67 × 102.85 mm, right half 169.84 × 102.85 mm. |
| **MCU** | 2× Raspberry Pi RP2040 (QFN-56) |
| **Flash** | 2× Winbond W25Q128JVPIQ (16 MB QSPI) |
| **LDO** | 2× TI LP5907SNX-3.3 (XDFN-4, 250 mA) |
| **Crystal** | 2× 12 MHz (Crystal_SMD_2520-4Pin) |
| **Switches** | 63× hybrid (Cherry-MX-compatible **or** Gateron KS-33 v2.0 low-profile, hot-swap) |
| **Stabilizers** | Kailh Choc V2 (2.25U + 2.75U + 2U backspace) |
| **RGB LEDs** | **127 total**: 63× per-key (SK6812MINI-E reverse-mount) + 64× underglow (SK6812 4020 side-view). Left 30 + 30 = 60, right 33 + 34 = 67. |
| **Host USB-C** | 2× HRO TYPE-C-31-M-12 (side-mounted, outer edge, 4 mm plank protrusion + 1 mm connector overhang) |
| **Inter-half USB-C** | 2× HRO TYPE-C-31-M-12 (top-edge mounted, near inner-top corner). Carries VBUS (+5V bridge), GND, and single-wire PIO serial on D+. |
| **Case hardware** | M2 × L4 × D3.5 heat-set inserts (3.3 mm holes) + M2 × 4 mm screws. |

Full sourcing detail in the [BOM](#bom).

## BOM

Quantities are rounded up to account for spares — order more than the minimum.

Part | Part number | Qty | Notes / Source
--- | --- | --- | ---
RP2040 MCU | RP2040 (QFN-56) | 2 | LCSC `C2040` / Mouser / DigiKey / direct from Raspberry Pi
QSPI Flash | Winbond W25Q128JVPIQ | 2 | LCSC `C190862` / Mouser / DigiKey
3.3V LDO | TI LP5907SNX-3.3 | 2 | LCSC `C133572` (XDFN-4, 1×1 mm) — 250 mA / 3.3 V. See [LDO history note](#ldo-history) below for why this instead of the Helios-spec'd TLV75533.
12 MHz crystal | 2520 4-pin SMD | 2 | LCSC `C2149204` / Mouser
USB-C receptacle (host + inter-half) | HRO TYPE-C-31-M-12 | 4 | LCSC `C165948` / JLC / AliExpress — same part used for all four positions (J1/J2 outer = host, J3/J4 top = inter-half)
USB ESD | USBLC6-2P6 | 2 | LCSC `C2827693` (SOT-666)
Polyfuse | SMD0805-075 (750 mA hold, 0805) | 2 | LCSC `C70060` — undersized for 127-LED rev2 typical draw (~1.3–1.4 A); upgrade to 2 A hold / 1206 (Bourns MF-NSMF200-2, LCSC `C89656`): schematic done, PCB footprint pending — see Stretch. (Rev1 used Bourns MF-FSMF050X-2, 500 mA / 0603.)
Ferrite bead | 600 Ω 0402 | 2 | LCSC `C160977`
Schottky diode | PMEG2010BELD (SOD-882) | 4 | LCSC `C552820` / DigiKey
Per-key LEDs | SK6812MINI-E (reverse mount) | 70+ | LCSC `C5149201` / AliExpress — order ~10% spare, fragile. Pin **numbers** between vendors differ but physical VDD/VSS/DIN/DOUT corners match
Underglow LEDs | SK6812SIDE-A 4020 side-view 4.0×2.0×1.5mm (thin 0.85mm variant same pads, e.g. Adafruit 4691) | 64 (30 left + 34 right) — order ~75 (15% spare) | OPSCO/Shenzhen Normand SK6812SIDE-A / SK68XX SIDE, Adafruit 4691 thin alt, Custom/Extended at JLC (no LCSC SIDE index found 2026-08-28), 5V 800kHz GRB, 4 pads 1mm pitch DIN/VDD/DOUT/GND left→right toward edge (+Y), **not** same as 5050 VSS/DIN/VDD/DOUT. See `footprints/SK6812-4020-SideView.pretty/` and `docs/rev2-4020-selection.md` for land pattern, rotation, and power notes
Switch diodes | 1N4148W (SOD-123) | 70+ | LCSC `C81598` / Mouser. Footprint `onigaku:D3_SMD_v2` is SOD-123, **not** SOD-323
Switches | Gateron KS-33 v2.0 low-profile **or** Cherry-MX-compatible | 63 (either type — hybrid footprint accepts both) | Keebio / Keychron / Gateron direct (hand-place; not from JLC stock)
Hot-swap sockets | Match to switch choice (KS33 sockets for KS-33, MX sockets for MX) | 63 | Same source as switches
Stabilizers | Kailh Choc V2 (2u for 2.25U, 2.75U, and 2U keys) | 2 sets | Choc V2 — **not** MX. Kailh has EOL'd this part — stock spares while retailers still have them. See [Stabilizers](#stabilizers) for the full story.
0603 100 nF ceramic caps | CC0603KRX7R9BB104 (or equiv 0.1µF X7R) | 150+ (147 in schematic — one per LED plus MCU/IC bypass) | LCSC auto-matches — confirm prompt is benign
0402 caps (LDO bypass) | varies (see schematic) | as schematic | LCSC `C1525` / `C15525` / `C52923` etc.
0402 resistors | varies | as schematic | LCSC `C25905` (5.1k, UNI-ROYAL) / `C11702` (1k, UNI-ROYAL) / `C60490` (10k, YAGEO) / `C138021` (27R, YAGEO) / `C25900` (4.7k, UNI-ROYAL) — 10k and 27R switched from UNI-ROYAL to YAGEO after recurring JLC stock shortages on UNI-ROYAL 0402 SKUs; the R30/R31 4.7k previously carried the 5.1k `C25905` code by mistake and is now correct
BOOTSEL push button | Panasonic EVP-BL2A1B000 SMD tact (1.9×2.8 mm footprint) | 2 | LCSC `C589221` — small; bigger case-pressable button still desired, see Stretch
0402 status LEDs | red / blue / green (per spec) | 4 | LCSC `C130719` / `C130724`
Case heat-set inserts | M2 × L4 × D3.5 brass knurled | as case dictates | Ruthex-style or equivalent — Amazon / AliExpress. Print 3.3 mm holes; heat-install with soldering iron ~200°C
Case screws | M2 × 4 mm machine screws | same qty as heat-set inserts | Any standard M2 × 4 — hardware store / Amazon / AliExpress
Rubber feet (sticky) | Adhesive-backed rubber pads | 4–8 per half | Sized to fit the recesses on the case bottom. Any standard "keyboard foot" or "furniture bumper" pack works — Amazon / AliExpress

## Software (QMK)

### Where the keyboard config lives

The umiko QMK keyboard definition lives in a **fresh clone of upstream QMK**, not in the older `idorurez/qmk_firmware` fork (which is on the `bakekujira` branch and carries stale history for an unrelated older board). Clean-slate approach:

```
git clone --depth 1 https://github.com/qmk/qmk_firmware.git ~/dev/keyboard/qmk_umiko
cd ~/dev/keyboard/qmk_umiko
git submodule update --init --recursive   # ~2 GB, ~10 min. Required for RP2040 (pico-sdk submodule)
```

The `keyboards/umiko/` folder lives in this repo: `keyboard.json` (matrix pins, 5×8 scanning matrix, split serial vendor driver on GP0, LAYOUT_all with 63 keys extracted from the schematic), `rules.mk`, `config.h`, `umiko.c`, `readme.md`, `keymaps/default/` + `keymaps/oled_test/`. Copy (or symlink) it into `qmk_umiko/keyboards/umiko/` when setting up a fresh clone. (TODO: `keyboard.json` still carries rev1 RGB counts — `led_count 90`, `split_count [42, 48]`. Rev2 needs 127 with split [60, 67] plus rev2 LED positions.)

### Toolchain (Windows)

QMK's CLI requires MSYS2 on Windows (its `MSYSTEM` environment check hard-fails in git-bash or plain shells).

**One-time setup**: [docs/toolchain-windows.md](docs/toolchain-windows.md) — exact MSYS2 install, pacman packages, QMK CLI pip, junction. Covers the Windows gotchas the QMK docs miss (jsonschema/rpds-py, `USERPROFILE`, `keyboard.json` vs `info.json`).

**Compile** (after setup):

| Script | What it does |
|---|---|
| `scripts/qmk_compile.sh [keymap]` | Wraps `qmk compile` inside MSYS2 with all the required env vars (USERPROFILE, HOME, PATH). No arg builds BOTH halves: `qmk_umiko/umiko_left.uf2` (from `default` keymap) + `qmk_umiko/umiko_right.uf2` (from `right` keymap, same code + right flag). With an arg, builds that keymap only. Flash the matching file per half. |

**Default keymap** (`keymaps/default/`): typing heatmap on per-key (black at rest, gold heat with halo falloff onto neighbors, overlapping presses stack to max) + white breathing underglow trim. The banked `.uf2` targets rev1 hardware (90 LEDs).

### QMK config: `keyboard.json` (NOT `info.json`)

Current QMK expects each keyboard folder to have `keyboard.json` at the top level (the old `info.json` name causes `qmk compile -kb umiko` to fail with `invalid keyboard_folder value`). Umiko's config is at `qmk_umiko/keyboards/umiko/keyboard.json`.

### Split handedness

Twin-binary scheme, no `SPLIT_HAND_PIN` / `MASTER_LEFT` / `EE_HANDS` / `SPLIT_USB_DETECT`: the `default` keymap builds LEFT and `right` builds RIGHT (side compiled in via `-DUMiko_RIGHT`). Either half can take the USB cable; the cabled half becomes master via VBUS detection on GPIO19 (divided local VBUS — the inter-half bridge lands post-diode, so only the USB-fed half reads high). Flash the matching file per half and plug USB into exactly one half (both plugged in = both claim master). TODO: confirm on hardware at first split test.

### Flash

Each half is flashed independently via BOOTSEL:

1. **Unplug USB** from the half you want to flash
2. **Hold the BOOTSEL button** on that half (SW1 left, SW2 right)
3. **Plug USB back in** while holding BOOTSEL
4. **Release BOOTSEL** — the half mounts as a USB mass-storage device (RPI-RP2)
5. **Drag-and-drop the `.uf2`** for that half onto the drive — it auto-reboots into the new firmware

Note: on this board the W25Q128 flash arrives blank from JLC, so first plug-in enters BOOTSEL automatically (RP2040 defaults to USB mass-storage mode when the QSPI flash contains no valid firmware). After first flash, subsequent re-flashes need the BOOTSEL button held.

No reset button on the board — power-cycle + BOOTSEL handles all flashing. Case access to SW1/SW2 is a design decision left to the case (rev1 uses pinhole access; case-integrated buttons still planned — see [Stretch](#stretch--future-ideas)).

### Split serial: what's happening on the wire

Umiko routes QMK's split-transport protocol over a **single-wire half-duplex PIO serial** running on **GP0** of each RP2040. GP0 connects to the D+ pin of each half's inter-half USB-C connector (J3 left, J4 right). A short USB-C-to-USB-C cable between J3 and J4 ties the two GP0 lines together and provides the 5V bridge (VBUS pins A4/A9) and GND (A12/B12).

QMK config:
- `keyboard.json` → `split.serial.driver = "vendor"` (uses RP2040 PIO peripheral for the serial protocol)
- `config.h` → `SERIAL_USART_TX_PIN = GP0` (single pin used for both TX and RX in half-duplex)

The inter-half USB-C is **not** a real USB port — it's just a convenient 4-conductor connector shape (VBUS + GND + D+). Do not plug either J3 or J4 into a computer or USB device.

## Assembly Notes

> ⚠️ **Hand-solder only the DNP parts. Get everything else JLCPCB-assembled.**
>
> **✅ Reasonable to hand-solder** (these are already DNP'd for exactly this reason):
> * **RGB LEDs (127, all hand-soldered)** — 63× per-key SK6812MINI-E (reverse-mount, light through PCB cutouts) + 64× underglow 4020 side-view (edge-mounted). Fragile and tedious but doable with flux and patience.
> * **Hot-swap sockets (match to switch choice)** — pre-tin the pads, place, reflow one pad at a time. Straightforward.
> * **HRO TYPE-C-31-M-12 USB-C connectors** — larger through-hole shield legs + reflowable SMD data pads. Manageable with a chisel tip.
>
> **❌ Do NOT attempt to hand-solder** (unless you're a professional with a reflow / hotplate / hot-air station):
> * **RP2040 (QFN-56 with exposed thermal pad)** — needs bottom heat. Ruining a $30 chip is very possible.
> * **LP5907 LDO (XDFN-4, 1×1 mm)** and **SN74LVC1T45 (SOT-563)** — pads so small they're barely visible without magnification.
> * **W25Q128 QSPI flash (WSON8)** — exposed pad on the bottom.
> * **USBLC6-2P6 (SOT-666)**, **PMEG2010BELD Schottky (SOD-882)** — sub-millimeter pitch.
> * **0402 passives, matrix diodes (SOD-123), crystal (SMD-2520)** — 0402 in particular is 90+ tiny caps that add up.
>
> **Get JLCPCB to place the "do NOT" list** via SMT assembly — see [Manufacturing Notes (JLCPCB)](#manufacturing-notes-jlcpcb) for the fab workflow, cost, and DNP configuration. Then do the ✅ list yourself when the boards come back.
>
> The Soldering Order / Hints / LEDs / Stabilizers sections below are for that hand-solder pass on the DNP parts (plus small rework as needed).

### Soldering Order

1. **Smallest components first** — 0402 resistors/caps, then 0603, then SMD ICs
2. **MCUs (RP2040)** — these have an exposed thermal pad on the bottom that needs to be soldered (heat from below, use a hotplate or reflow station). Hand-soldering with a fine tip is doable but tricky.
3. **Flash chips, LDOs, ESD protection** — small SMD work
4. **Crystals** — fragile, place after the heavy soldering nearby is done
5. **USB-C receptacles** (HRO TYPE-C-31-M-12) — SMD signal pads + 4 THT shield legs + 2 NPTH alignment pegs; body sits on top of the PCB. Can be reflowed or hand-soldered.
6. **LEDs** — start with underglow (back side), then per-key (front side). Test as you solder.
7. **Switch sockets** (Kailh / Gateron KS33 hot-swap) — last to give all-around access during earlier soldering
8. **Stabilizers** — clip in before testing switches
9. **Switches** — plug in last, after firmware flash works

### Soldering Hints

* For 0402 / 0603 SMD pads, **flux liberally** and keep your tip tinned with a fine bead of solder
* For Kailh / KS-33 hot-swap sockets, **pre-tin both pads**, then place the socket and reheat one pad at a time while pressing down
* For RP2040's exposed thermal pad, **use the via stitching as a heat sink** — solder paste + hot air, or paste + skillet reflow

### LEDs

* **Per-key MINI-E are reverse-mounted** — pads on B.Cu, body recessed in the PCB cutout, light shines through to the keycap. **Underglow 4020s are edge-mounted side-view** (B.Cu pads); pin 1 is the filled dot on silk/F.Fab and `EMIT` text marks the light-exit side. **Bend the terminals down to the soldering pads** before reflowing or hand-soldering.
* **Solder LEDs in the data chain order** and **test as you go** — if one is bad, all LEDs after it in the chain won't light up
* If an LED looks broken or melted after soldering, it's probably broken — desolder and replace

### Stabilizers

**Kailh Choc V2 stabilizers** on all 6 stabbed positions (2.25U shifts + 2.75U thumbs + 2U backspace). Standard MX stabs won't fit. Kailh **EOL'd this part in 2026** — stock spares from retailer inventory while it lasts.

**Not Gateron LP** — per bakingpy (Keebio, author of `keebio/kb-plategen`): Gateron LP stabs mechanically limit switch travel so keys don't bottom out fully; no cutout tweak fixes it.
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
## KiCad design umiko.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132, C133, C134, C135, C136, C137, C138, C139, C140, C141, C143, C144, C145, C146, C147, C148, C149, C150, C151, C152, C153, C154, C155, C156, C157, C158, C159, C160: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5b1, C5b2, C43, C45, C72, C73: 10u; C_0402_1005Metric; MPN 10uF 20% 10V 0402; LCSC C15525
C6_A1, C6_A2, C50, C51, C52, C53, C54, C55, C56, C57, C58, C63, C64, C65, C66, C67, C68, C69, C70, C71: 100n; C_0402_1005Metric; MPN 100nF 10% 10V 0402; LCSC C1525
C46, C47, C59, C60: 15p; C_0402_1005Metric; MPN 15pF 5% 10V; LCSC C1548
C48, C49, C61, C62: 1u; C_0402_1005Metric; MPN 1uF 20% 10V 0402; LCSC C52923
D1, D5: PMEG2010BELD; SOD882D; MPN PMEG2010BELD,315; JLCPCB_CORRECTION 0; 0; 180
D2, D6: Power LED; D_0402_1005Metric; MPN B1811URO-20D000113U1930; LCSC C130719
D3, D4: User LED; D_0402_1005Metric; MPN B1811NB--05D000113U1930; LCSC C130724
D_1, D_2, D_3, D_4, D_5, D_6, D_7, D_8, D_9, D_10, D_11, D_12, D_13, D_14, D_15, D_16, D_17, D_18, D_19, D_20, D_21, D_22, D_23, D_24, D_25, D_26, D_27, D_28, D_29, D_30, D_31, D_32, D_33, D_34, D_35, D_36, D_37, D_38, D_39, D_40, D_41, D_42, D_43, D_44, D_45, D_46, D_47, D_48, D_49, D_50, D_51, D_52, D_53, D_54, D_55, D_56, D_57, D_58, D_59, D_60, D_61, D_62, D_63: D; D3_SMD_v2
F1, F2: 2A; Fuse_1206_3216Metric; MPN MF-NSMF200-2; LCSC C89656
FB1, FB2: 600R; R_0402_1005Metric; MPN BLM15PX601SN1D; LCSC C160977
J1, J2, J3, J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN USB4510-03-1-A; LCSC C165948
LED1, LED2, LED3, LED4, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED19, LED20, LED21, LED22, LED23, LED26, LED27, LED28, LED29, LED32, LED33, LED34, LED35, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED50, LED51, LED52, LED53, LED56, LED57, LED58, LED59, LED62, LED63, LED64, LED65, LED66, LED69, LED70, LED71, LED72, LED73, LED76, LED77, LED78, LED80, LED81, LED82, LED83, LED85, LED86, LED87: YS-SK6812MINI-E
LED5, LED6, LED15, LED16, LED17, LED18, LED24, LED25, LED30, LED31, LED36, LED37, LED48, LED49, LED54, LED55, LED60, LED61, LED67, LED68, LED74, LED75, LED79, LED84, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED120, LED121, LED122, LED123, LED124, LED125, LED126, LED127: SK6812-4020-SideView
R1, R27: 500; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R6, R13, R19, R21, R22, R24, R25, R26: 5.1k; R_0402_1005Metric; MPN 5.1k 1% 0402; LCSC C25905
R7, R23: 2.2k; R_0402_1005Metric; MPN 1k 1% 0402; LCSC C11702
R8, R14, R20, R22_R1: 10k; R_0402_1005Metric; MPN RC0402FR-0710KL; LCSC C60490
R9, R10, R15, R16: 27; R_0402_1005Metric; MPN RC0402FR-0727RL; LCSC C138021
R11, R12, R17, R18: 1k; R_0402_1005Metric; MPN 1k 1% 0402; LCSC C11702
SW1, SW2: SWITCH; 1.9x2.8mm SW; MPN EVP-BL2A1B000; LCSC C589221
SW_1, SW_5, SW_8, SW_9, SW_10, SW_11, SW_13, SW_14, SW_15, SW_16, SW_18, SW_19, SW_20, SW_21, SW_22, SW_23, SW_24, SW_25, SW_26, SW_27, SW_28, SW_29, SW_31, SW_32, SW_33, SW_34, SW_36, SW_37, SW_38, SW_39, SW_40, SW_41, SW_42, SW_43, SW_44, SW_45, SW_46, SW_47, SW_49, SW_50, SW_51, SW_52, SW_54, SW_55, SW_56, SW_57: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_1U
SW_2, SW_62: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_1.5U
SW_3: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_1.75U
SW_4, SW_7, SW_12, SW_17, SW_48, SW_53, SW_60, SW_63: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_1.25U
SW_6, SW_30, SW_58: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_Stabilized_2.25U
SW_35, SW_59: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_Stabilized_2.75U
SW_61: KEYSW; SW_MX_Gateron_LowProfile_Hybrid_THT_Stabilized_2U
U1, U9: USBLC6-2P6; SOT-666; MPN USBLC6-2P6; JLCPCB_CORRECTION 0; 0; 270
U2, U10: LP5907SNX-3.3; X2SON-4; MPN LP5907SNX-3.3; LCSC C133572
U3, U6: W25Q128JVPIQ; MPN W25Q128JVPIQ; JLCPCB_CORRECTION 0; 0; 270
U5, U8: SN74LVC1T45DRL; SOT-563; MPN SN74LVC1T45DRLR; JLCPCB_CORRECTION 0; 0; 270
U7: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; MPN SC0914(13); LCSC C2040
U11: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC C2040
U12: LS011B7DH03_Breakout
Y1, Y2: 12MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm; MPN ECS-120-10-36B-CWY-TR3; LCSC C2149204

Connections (part):
+1V1_L: C49.2, C56.1, C58.1, U11.23 (DVDD), U11.45 (VREG_VOUT), U11.50 (DVDD)
+1V1_R: C62.2, C69.1, C71.1, U7.23 (DVDD), U7.45 (VREG_VOUT), U7.50 (DVDD)
+3V3_L: C5b1.1, C6_A1.1, C48.2, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C57.1, D2.2 (A), R8.1, U2.1 (Vout), U3.8 (VCC), U5.1 (VCCA), U5.5 (DIR), U11.1 (IOVDD), U11.10 (IOVDD), U11.22 (IOVDD), U11.33 (IOVDD), U11.42 (IOVDD), U11.43 (ADC_AVDD), U11.44 (VREG_VIN), U11.48 (USB_VDD), U11.49 (IOVDD)
+3V3_R: C5b2.1, C6_A2.1, C61.2, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C70.1, D6.2 (A), R22_R1.1, U6.8 (VCC), U7.1 (IOVDD), U7.10 (IOVDD), U7.22 (IOVDD), U7.33 (IOVDD), U7.42 (IOVDD), U7.43 (ADC_AVDD), U7.44 (VREG_VIN), U7.48 (USB_VDD), U7.49 (IOVDD), U8.1 (VCCA), U8.5 (DIR), U10.1 (Vout), U12.3 (VCC_3)
+5V_L: C1.1, C2.1, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.2, C25.1, C26.1, C27.1, C28.1, C29.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.2, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.2, C45.1, C75.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.1, C136.2, C137.2, C138.2, C139.2, D1.1 (K), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.2 (VDD), LED6.2 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD)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
+5V_R: C73.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, C86.2, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.2, C100.1, C101.2, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.2, C113.1, C114.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C121.2, C122.2, C140.1, C141.1, C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.2, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.2, C159.1, C160.2, D5.1 (K), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), LED43.1 (VDD), LED44.1 (VDD), LED45.1 (VDD), LED46.1 (VDD), LED47.1 (VDD), LED48.2 (VDD), LED50.1 (VDD)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
/1_RX0_L: U11.3 (GPIO1)
/1_RX0_R: U7.3 (GPIO1)
/20_SDI_L: U11.31 (GPIO20)
/20_SDI_R: U7.31 (GPIO20)
/21_CS_L: U11.32 (GPIO21)
/21_CS_R: U7.32 (GPIO21)
/22_SCK_L: U11.34 (GPIO22)
/22_SCK_R: U7.34 (GPIO22)
/23_SDO_L: U11.35 (GPIO23)
/23_SDO_R: U7.35 (GPIO23)
/A0_L: U11.38 (GPIO26/ADC0)
/A0_R: U7.38 (GPIO26/ADC0)
/A1_L: U11.39 (GPIO27/ADC1)
/A1_R: U7.39 (GPIO27/ADC1)
/A2_L: U11.40 (GPIO28/ADC2)
/A2_R: U7.40 (GPIO28/ADC2)
/A3_L: U11.41 (GPIO29/ADC3)
/A3_R: U7.41 (GPIO29/ADC3)
/D+_L: R9.2, U11.47 (D+)
/D+_R: R15.2, U7.47 (D+)
/D-_L: R10.2, U11.46 (D-)
/D-_R: R16.2, U7.46 (D-)
/PORT_L+: J1.A6 (D+), J1.B6 (D+), U1.6 (I/O1)
/PORT_L-: J1.A7 (D-), J1.B7 (D-), U1.4 (I/O2)
/PORT_R+: J2.A6 (D+), J2.B6 (D+), U9.6 (I/O1)
/PORT_R-: J2.A7 (D-), J2.B7 (D-), U9.4 (I/O2)
/QSPI_CLK_L: U3.6 (CLK), U11.52 (QSPI_SCLK)
/QSPI_CLK_R: U6.6 (CLK), U7.52 (QSPI_SCLK)
/QSPI_CS_L: R8.2, SW1.2, U3.1 (/CS), U11.56 (QSPI_SS_N)
/QSPI_CS_R: R22_R1.2, SW2.2, U6.1 (/CS), U7.56 (QSPI_SS_N)
/QSPI_SD0_L: U3.5 (DI(IO0)), U11.53 (QSPI_SD0)
/QSPI_SD0_R: U6.5 (DI(IO0)), U7.53 (QSPI_SD0)
/QSPI_SD1_L: U3.2 (DO(IO1)), U11.55 (QSPI_SD1)
/QSPI_SD1_R: U6.2 (DO(IO1)), U7.55 (QSPI_SD1)
/QSPI_SD2_L: U3.3 (IO2), U11.54 (QSPI_SD2)
/QSPI_SD2_R: U6.3 (IO2), U7.54 (QSPI_SD2)
/QSPI_SD3_L: U3.7 (IO3), U11.51 (QSPI_SD3)
/QSPI_SD3_R: U6.7 (IO3), U7.51 (QSPI_SD3)
/RGB_DO_L: U5.3 (A), U11.37 (GPIO25)
/RGB_DO_R: U7.37 (GPIO25), U8.3 (A)
/SWD_CLK_L: U11.24 (SWCLK)
/SWD_CLK_R: U7.24 (SWCLK)
/SWD_IO_L: U11.25 (SWDIO)
/SWD_IO_R: U7.25 (SWDIO)
/USB+L: R9.1, U1.1 (I/O1)
/USB+R: R15.1, U9.1 (I/O1)
/USB-L: R10.1, U1.3 (I/O2)
/USB-R: R16.1, U9.3 (I/O2)
/USER_LED_L: D3.2 (A), U11.28 (GPIO17)
/USER_LED_R: D4.2 (A), U7.28 (GPIO17)
/VBUS_DETECT_L: R13.2, R14.1, U11.30 (GPIO19)
/VBUS_DETECT_R: R19.2, R20.1, U7.30 (GPIO19)
GND_L: C1.2, C2.2, C3.2, C4.2, C5.1, C5b1.2, C6.2, C6_A1.2, C7.2, C8.2, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.2, C32.2, C33.2, C34.2, C35.1, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, C43.2, C45.2, C46.1, C47.1, C48.1, C49.1, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C75.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, C135.2, C136.1, C137.1, C138.1, C139.1, FB1.2, J1.A1 (GND), J1.A12 (GND)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
LED_L: R1.2, U5.4 (B)
LED_R: R27.2, U8.4 (B)
MIP_CS_R: U7.36 (GPIO24), U12.5 (MOSI_1)
MIP_MOSI_R: U7.5 (GPIO3), U12.1 (CS_5)
unnamed: C47.2, R11.1, Y1.1
unnamed: C60.2, R17.1, Y2.1
unnamed: D1.2 (A), F1.2
unnamed: D2.1 (K), R7.1
unnamed: D3.1 (K), R12.1
unnamed: D4.1 (K), R18.1
unnamed: D5.2 (A), F2.2
unnamed: D6.1 (K), R23.1
unnamed: D_1.2 (A), SW_1.2 (ROW)
unnamed: D_2.2 (A), SW_2.2 (ROW)
unnamed: D_3.2 (A), SW_3.2 (ROW)
unnamed: D_4.2 (A), SW_4.2 (ROW)
unnamed: D_5.2 (A), SW_5.2 (ROW)
unnamed: D_6.2 (A), SW_6.2 (ROW)
unnamed: D_7.2 (A), SW_7.2 (ROW)
unnamed: D_8.2 (A), SW_8.2 (ROW)
unnamed: D_9.2 (A), SW_9.2 (ROW)
unnamed: D_10.2 (A), SW_10.2 (ROW)
unnamed: D_11.2 (A), SW_11.2 (ROW)
unnamed: D_12.2 (A), SW_12.2 (ROW)
unnamed: D_13.2 (A), SW_13.2 (ROW)
unnamed: D_14.2 (A), SW_14.2 (ROW)
unnamed: D_15.2 (A), SW_15.2 (ROW)
unnamed: D_16.2 (A), SW_16.2 (ROW)
unnamed: D_17.2 (A), SW_17.2 (ROW)
unnamed: D_18.2 (A), SW_18.2 (ROW)
unnamed: D_19.2 (A), SW_19.2 (ROW)
unnamed: D_20.2 (A), SW_20.2 (ROW)
unnamed: D_21.2 (A), SW_21.2 (ROW)
unnamed: D_22.2 (A), SW_22.2 (ROW)
unnamed: D_23.2 (A), SW_23.2 (ROW)
unnamed: D_24.2 (A), SW_24.2 (ROW)
unnamed: D_25.2 (A), SW_25.2 (ROW)
unnamed: D_26.2 (A), SW_26.2 (ROW)
unnamed: D_27.2 (A), SW_27.2 (ROW)
unnamed: D_28.2 (A), SW_28.2 (ROW)
unnamed: D_29.2 (A), SW_29.2 (ROW)
unnamed: D_30.2 (A), SW_30.2 (ROW)
unnamed: D_31.2 (A), SW_31.2 (ROW)
unnamed: D_32.2 (A), SW_32.2 (ROW)
unnamed: D_33.2 (A), SW_33.2 (ROW)
unnamed: D_34.2 (A), SW_34.2 (ROW)
unnamed: D_35.2 (A), SW_35.2 (ROW)
unnamed: D_36.2 (A), SW_36.2 (ROW)
unnamed: D_37.2 (A), SW_37.2 (ROW)
unnamed: D_38.2 (A), SW_38.2 (ROW)
unnamed: D_39.2 (A), SW_39.2 (ROW)
unnamed: D_40.2 (A), SW_40.2 (ROW)
unnamed: D_41.2 (A), SW_41.2 (ROW)
unnamed: D_42.2 (A), SW_42.2 (ROW)
unnamed: D_43.2 (A), SW_43.2 (ROW)
unnamed: D_44.2 (A), SW_44.2 (ROW)
unnamed: D_45.2 (A), SW_45.2 (ROW)
unnamed: D_46.2 (A), SW_46.2 (ROW)
unnamed: D_47.2 (A), SW_47.2 (ROW)
unnamed: D_48.2 (A), SW_48.2 (ROW)
unnamed: D_49.2 (A), SW_49.2 (ROW)
unnamed: D_50.2 (A), SW_50.2 (ROW)
unnamed: D_51.2 (A), SW_51.2 (ROW)
unnamed: D_52.2 (A), SW_52.2 (ROW)
unnamed: D_53.2 (A), SW_53.2 (ROW)
unnamed: D_54.2 (A), SW_54.2 (ROW)
unnamed: D_55.2 (A), SW_55.2 (ROW)
unnamed: D_56.2 (A), SW_56.2 (ROW)
unnamed: D_57.2 (A), SW_57.2 (ROW)
unnamed: D_58.2 (A), SW_58.2 (ROW)
unnamed: D_59.2 (A), SW_59.2 (ROW)
unnamed: D_60.2 (A), SW_60.2 (ROW)
unnamed: D_61.2 (A), SW_61.2 (ROW)
unnamed: D_62.2 (A), SW_62.2 (ROW)
unnamed: D_63.2 (A), SW_63.2 (ROW)
unnamed: FB1.1, J1.S1 (SHIELD)
unnamed: FB2.1, J2.S1 (SHIELD)
unnamed: J1.A5 (CC1), R4.2
unnamed: J1.B5 (CC2), R5.2
unnamed: J2.A5 (CC1), R21.2
unnamed: J2.B5 (CC2), R22.2
unnamed: J3.A5 (CC1), R6.2
unnamed: J3.B5 (CC2), R24.2
unnamed: J4.A5 (CC1), R25.2
unnamed: J4.B5 (CC2), R26.2
unnamed: LED1.4 (DIN), LED106.3 (DOUT)
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED9.4 (DIN)
unnamed: LED5.1 (DIN), LED6.3 (DOUT)
unnamed: LED5.3 (DOUT), LED95.1 (DIN)
unnamed: LED7.4 (DIN), LED8.2 (DOUT)
unnamed: LED8.4 (DIN), LED9.2 (DOUT)
unnamed: LED7.2 (DOUT), LED10.4 (DIN)
unnamed: LED10.2 (DOUT), LED11.4 (DIN)
unnamed: LED11.2 (DOUT), LED12.4 (DIN)
unnamed: LED12.2 (DOUT), LED13.4 (DIN)
unnamed: LED13.2 (DOUT), LED14.4 (DIN)
unnamed: LED14.2 (DOUT), LED23.4 (DIN)
unnamed: LED15.1 (DIN), LED17.3 (DOUT)
unnamed: LED6.1 (DIN), LED15.3 (DOUT)
unnamed: LED16.1 (DIN), R1.1
unnamed: LED16.3 (DOUT), LED18.1 (DIN)
unnamed: LED17.1 (DIN), LED24.3 (DOUT)
unnamed: LED18.3 (DOUT), LED25.1 (DIN)
unnamed: LED19.4 (DIN), LED20.2 (DOUT)
unnamed: LED19.2 (DOUT), LED26.4 (DIN)
unnamed: LED20.4 (DIN), LED21.2 (DOUT)
unnamed: LED21.4 (DIN), LED22.2 (DOUT)
unnamed: LED22.4 (DIN), LED23.2 (DOUT)
unnamed: LED24.1 (DIN), LED30.3 (DOUT)
unnamed: LED25.3 (DOUT), LED31.1 (DIN)
unnamed: LED26.2 (DOUT), LED27.4 (DIN)
unnamed: LED27.2 (DOUT), LED28.4 (DIN)
unnamed: LED28.2 (DOUT), LED29.4 (DIN)
unnamed: LED29.2 (DOUT), LED35.4 (DIN)
unnamed: LED30.1 (DIN), LED36.3 (DOUT)
unnamed: LED31.3 (DOUT), LED37.1 (DIN)
unnamed: LED32.4 (DIN), LED33.2 (DOUT)
unnamed: LED32.2 (DOUT), LED38.4 (DIN)
unnamed: LED33.4 (DIN), LED34.2 (DOUT)
unnamed: LED34.4 (DIN), LED35.2 (DOUT)
unnamed: LED36.1 (DIN), LED37.3 (DOUT)
unnamed: LED38.2 (DOUT), LED39.4 (DIN)
unnamed: LED39.2 (DOUT), LED40.4 (DIN)
unnamed: LED40.2 (DOUT), LED41.4 (DIN)
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
Notes on the sheet:
Keyboard Matrix Left
RGB Circuit Left
RP2040, 16MB QSPI flash and level shifter for LEDs
USB, ESD protection and Power, Left
USB, ESD protection and Power, Right

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
Board: 4 copper layers, 328.6 x 102.8 mm, 469 parts (330 on the bottom side), 284 nets.

## Commit log (part)

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2021-03-29 fixing split and rgb source
2021-04-19 latest sanity upload
2021-05-06 readme and small udpates
2025-11-15 first copy paste commit
2025-11-15 re-rename
2025-11-15 rename
2025-11-17 more wiring
2025-11-30 schema updated for jst to daughter board
2025-12-17 4 layers, incorporating design
2026-01-09 flipped usb c
2026-01-14 more trace work
2026-01-15 more tracing
2026-01-16 more tracin
2026-01-18 left side first pass
2026-01-29 moved leds up
2026-01-30 more tracing, left side only
2026-02-06 moving chips closer
2026-02-08 before claude
2026-03-05 painfully deciding where to move footprints for best access

Notices in the files:
README.md:
License:
PCB files: CERN OHL v2 — Permissive (or your preferred license; verify before forking).
Firmware: GPL-2.0 (inherited from QMK).
